# Keil uVision project ORKO_Slave.uvprojx, settings and files
target ORKO_Sim (ARM-ADS)
  device: M031FB0AE Nuvoton
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: orko_sim +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: ORKO_SIM
  c include: .\app;.\algo;.\sim;.\drivers;.\sensors;.\lora;.\power
  group Algorithm
    ./algo/: fire_score.c fire_score.h
  group Application
    ./app/: orko_config.h main.c
  group Simulation
    ./sim/: sim_main.c sim_display.c sim_display.h fake_sensors.c fake_sensors.h sim_uart.c
  group Sensors
    ./sensors/: drv_bmp390.c drv_bmp390.h drv_hdc2022.c drv_hdc2022.h drv_mq9.c drv_mq9.h drv_neo7m.c drv_neo7m.h drv_scd40.c drv_scd40.h
  group Drivers
    ./drivers/: hal_adc.c hal_adc.h hal_i2c.c hal_i2c.h hal_timer.c hal_timer.h hal_uart.c hal_uart.h
  group LoRa
    ./lora/: lora_e22.c lora_e22.h
  group Power
    ./power/: power_mgmt.c power_mgmt.h
  group Startup
    ./startup/: startup_M031Series.s
